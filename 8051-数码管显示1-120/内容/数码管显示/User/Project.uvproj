# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\User
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: Init.c Init.h Seg.c Seg.h
